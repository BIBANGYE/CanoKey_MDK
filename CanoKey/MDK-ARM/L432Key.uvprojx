# Keil uVision project L432Key.uvprojx, settings and files
target L432Key (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32L432KCUx STMicroelectronics
  pack: Keil.STM32L4xx_DFP.2.6.1
  cpu: IRAM(0x20000000,0x0000C000) IRAM2(0x10000000,0x00004000) IROM(0x08000000,0x00040000) CPUTYPE("Cortex-M4") FPU2 DSP CLOCK(12000000) ELITTLE
  output: L432Key +hex
  group MDK-ARM
    ./: startup_stm32l432xx.s
  group CMSIS
    ../Src/: system_stm32l4xx.c
  group STM32L4xx_HAL_Driver
    ../Drivers/STM32L4xx_HAL_Driver/Src/: stm32l4xx_hal_pcd.c stm32l4xx_hal_pcd_ex.c stm32l4xx_ll_usb.c stm32l4xx_hal.c stm32l4xx_hal_i2c.c stm32l4xx_hal_i2c_ex.c stm32l4xx_hal_rcc.c stm32l4xx_hal_rcc_ex.c stm32l4xx_hal_flash.c stm32l4xx_hal_flash_ex.c stm32l4xx_hal_flash_ramfunc.c stm32l4xx_hal_gpio.c stm32l4xx_hal_dma.c stm32l4xx_hal_dma_ex.c stm32l4xx_hal_pwr.c stm32l4xx_hal_pwr_ex.c stm32l4xx_hal_cortex.c stm32l4xx_hal_exti.c stm32l4xx_hal_uart.c stm32l4xx_hal_uart_ex.c stm32l4xx_hal_rng.c stm32l4xx_hal_spi.c stm32l4xx_hal_spi_ex.c stm32l4xx_hal_tim.c stm32l4xx_hal_tim_ex.c
  group User
    ../Src/: admin_vendor.c device.c lfs_init.c retarget.c stm32l4xx_hal_msp.c stm32l4xx_it.c usbd_conf.c main.c
  group applets
    ../canokey-core/applets/admin/: admin.c
    ../canokey-core/applets/ctap/: ctap.c ctap-parser.c secret.c u2f.c
    ../canokey-core/applets/meta/: meta.c
    ../canokey-core/applets/ndef/: ndef.c
    ../canokey-core/applets/oath/: oath.c
    ../canokey-core/applets/openpgp/: key.c openpgp.c
    ../canokey-core/applets/piv/: piv.c
  group crypto
    ../canokey-core/canokey-crypto/src/: aes.c block-cipher.c crypto-util.c cv25519.c des.c ecc.c ed25519.c hmac.c memzero.c rand.c rsa.c sha.c sha3.c
  group USB_core
    ../canokey-core/interfaces/USB/core/src/: usbd_core.c usbd_ctlreq.c usbd_ioreq.c
  group USB_device
    ../canokey-core/interfaces/USB/device/: usb_device.c usbd_canokey.c usbd_desc.c usbd_desc.h
  group USB_class
    ../canokey-core/interfaces/USB/class/ccid/: ccid.c usbd_ccid.c
    ../canokey-core/interfaces/USB/class/ctaphid/: ctaphid.c usbd_ctaphid.c
    ../canokey-core/interfaces/USB/class/kbdhid/: kbdhid.c usbd_kbdhid.c
    ../canokey-core/interfaces/USB/class/webusb/: webusb.c
  group NFC
    ../canokey-core/interfaces/NFC/: fm.c nfc.c
  group littlefs
    ../canokey-core/littlefs/bd/: lfs_filebd.c lfs_rambd.c lfs_testbd.c
    ../canokey-core/littlefs/: lfs.c lfs_util.c
  group apdu
    ../canokey-core/src/: apdu.c applets.c common.c device.c fs.c pin.c
  group tinycbor
    ../canokey-core/tinycbor/src/: cborencoder.c cborencoder_close_container_checked.c cborerrorstrings.c cborparser.c cborparser_dup_string.c cborpretty.c cborpretty_stdio.c cbortojson.c cborvalidation.c open_memstream.c
  group virt-card
    ../canokey-core/virt-card/: device-sim.c fabrication.c ffs.c fido-hid-over-udp.c ifdhandler.c qemu.c usb-dummy.c usbip.c
software components: CMSIS:CORE 5.5.0
